Commit message: add : lider_urdf

File: urdf/subject2.urdf (robot description, URDF)
Before this commit: robot subject, 2 links, 1 joints
Joints:
- joint ball_joint: origin xyz=2 0.1 0 rpy=0 0 0 -> xyz=1.5 1 0 rpy=0 0 0
